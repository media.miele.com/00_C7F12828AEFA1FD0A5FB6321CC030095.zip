Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 1739b50a-fa8e-4d16-b69f-946900a973a1, NumberOfSaves: 1]
File name: 0001
Time: 2025-09-17T08:56:22+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12799110_EX2_PLW8683SST_LD:62868364_EX2_12799110_PLW8683SST_LD, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Design_Cast, z_Miele_Design_Glass, z_Miele_Design_GRGR, <Unnamed>, z_Miele_Connection_Water_IN, z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, z_Miele_Connection_Connection_Modul, z_Miele_Connection_Liquid Detergent, z_Miele_Connection_Network
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: 62868364_EX2_12799110_PLW8683SST_LD; sets with these values: 2
